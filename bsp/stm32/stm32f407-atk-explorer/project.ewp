# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; STM32F407xx; __RTTHREAD__; USE_HAL_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\os\rt-thread\components\finsh; ..\libraries\HAL_Drivers\drivers; ..\libraries\HAL_Drivers\drivers\config; ..\..\..\..\os\rt-thread\components\drivers\include; ..\..\..\..\os\rt-thread\components\libc\compilers\common\extension; board\CubeMX_Config\Inc; ..\..\..\..\os\rt-thread\components\libc\posix\ipc; ..\libraries\HAL_Drivers\CMSIS\Include; .; board; ..\libraries\HAL_Drivers; ..\..\..\..\os\rt-thread\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\os\rt-thread\components\libc\posix\io\epoll; ..\..\..\..\os\rt-thread\components\libc\compilers\common\include; ..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; board\ports; ..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; applications; ..\..\..\..\os\rt-thread\components\libc\posix\io\poll; ..\..\..\..\os\rt-thread\include; ..\..\..\..\os\rt-thread\libcpu\arm\common; ..\..\..\..\os\rt-thread\libcpu\arm\cortex-m4; ..\..\..\..\os\rt-thread\components\libc\posix\io\eventfd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../../os/rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../os/rt-thread/components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../os/rt-thread/components/drivers/core/: device.c
    ../../../../os/rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../../os/rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../os/rt-thread/components/drivers/pin/: pin.c
    ../../../../os/rt-thread/components/drivers/serial/: serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_soft_i2c.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../../os/rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../os/rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../os/rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../os/rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../os/rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_gpio.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
