# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CLK_TCK=RT_TICK_PER_SECOND, STM32F407xx, __RTTHREAD__, USE_HAL_DRIVER, RT_USING_ARMLIBC, RT_USING_LIBC, __STDC_LIMIT_MACROS
  c include: ..\..\..\..\os\rt-thread\components\drivers\include;..\libraries\HAL_Drivers\drivers\config;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\vendor\wifi;..\..\..\..\os\rt-thread\components\drivers\include;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\..\..\os\rt-thread\components\libc\posix\ipc;..\libraries\HAL_Drivers;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\video;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\dfu;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb;board\ports;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\core;..\..\..\..\os\rt-thread\components\libc\compilers\common\include;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\hid;..\..\..\..\os\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\os\rt-thread\components\drivers\include;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\adb;..\..\..\..\os\rt-thread\components\libc\posix\io\epoll;..\..\..\..\os\rt-thread\components\ros\ros;..\..\..\..\os\rt-thread\components\utilities\ulog;..\..\..\..\os\rt-thread\components\libc\compilers\common\extension;applications;board\CubeMX_Config\Inc;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\msc;..\..\..\..\os\rt-thread\libcpu\arm\cortex-m4;..\..\..\..\os\rt-thread\libcpu\arm\common;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\audio;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\wireless;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\hub;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\vendor\net;..\..\..\..\os\rt-thread\components\finsh;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\common;..\..\..\..\os\rt-thread\components\libc\posix\io\eventfd;..\..\..\..\os\rt-thread\components\libc\posix\io\poll;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\midi;..\..\..\..\os\rt-thread\components\drivers\include;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\vendor\serial;.;board;..\..\..\..\os\rt-thread\components\ros;..\..\..\..\os\rt-thread\components\drivers\smp;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\cdc;..\libraries\HAL_Drivers\drivers;..\..\..\..\os\rt-thread\include;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\class\mtp;..\..\..\..\os\rt-thread\components\drivers\usb\cherryusb\osal
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CherryUSB
    ../../../../os/rt-thread/components/drivers/usb/cherryusb/platform/rtthread/: usb_check.c usb_msh.c
    ../../../../os/rt-thread/components/drivers/usb/cherryusb/demo/: cdc_acm_template.c
    ../../../../os/rt-thread/components/drivers/usb/cherryusb/port/dwc2/: usb_dc_dwc2.c usb_glue_st.c
    ../../../../os/rt-thread/components/drivers/usb/cherryusb/core/: usbd_core.c
    ../../../../os/rt-thread/components/drivers/usb/cherryusb/class/cdc/: usbd_cdc_acm.c
    ../../../../os/rt-thread/components/drivers/usb/cherryusb/osal/: usb_osal_rtthread.c
  group Compiler
    ../../../../os/rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../os/rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../os/rt-thread/components/drivers/core/: device.c
    ../../../../os/rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../os/rt-thread/components/drivers/pin/: dev_pin.c
    ../../../../os/rt-thread/components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../../os/rt-thread/components/finsh/: shell.c msh_parse.c msh.c cmd.c
  group Kernel
    ../../../../os/rt-thread/src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../os/rt-thread/src/klibc/: kerrno.c kstdio.c kstring.c
  group libcpu
    ../../../../os/rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../os/rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_cryp.c stm32f4xx_hal.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cec.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group ros
    ../../../../os/rt-thread/components/ros/: ANO_DT.c
  group Utilities
    ../../../../os/rt-thread/components/utilities/ulog/backend/: console_be.c
    ../../../../os/rt-thread/components/utilities/ulog/: ulog.c
