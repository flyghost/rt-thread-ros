# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_LIBC, __RTTHREAD__, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_HAL_DRIVER, STM32F103xB
  c include: ..\..\..\..\os\rt-thread\components\libc\posix\ipc;..\libraries\HAL_Drivers\drivers\config;..\..\..\..\os\rt-thread\include;..\libraries\HAL_Drivers;board;..\..\..\..\os\rt-thread\components\dfs\dfs_v1\include;..\libraries\HAL_Drivers\drivers;..\..\..\..\os\rt-thread\components\finsh;..\..\..\..\os\rt-thread\components\drivers\include;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;board\ports;..\..\..\..\os\rt-thread\components\libc\posix\io\poll;.;..\..\..\..\os\rt-thread\libcpu\arm\common;..\..\..\..\os\rt-thread\components\drivers\include;board\CubeMX_Config\Inc;..\..\..\..\os\rt-thread\components\libc\compilers\common\include;..\..\..\..\os\rt-thread\components\libc\posix\io\eventfd;..\..\..\..\os\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\os\rt-thread\components\drivers\include;..\..\..\..\os\rt-thread\components\libc\posix\io\epoll;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\..\..\..\os\rt-thread\libcpu\arm\cortex-m3;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\..\os\rt-thread\components\drivers\include;applications;..\..\..\..\os\rt-thread\components\libc\compilers\common\extension
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../../os/rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../os/rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../os/rt-thread/components/drivers/core/: device.c
    ../../../../os/rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../os/rt-thread/components/drivers/pin/: dev_pin.c
    ../../../../os/rt-thread/components/drivers/serial/: serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    board/ports/: user_key.c
  group Filesystem
    ../../../../os/rt-thread/components/dfs/dfs_v1/src/: dfs_fs.c dfs_file.c dfs.c dfs_posix.c
  group Finsh
    ../../../../os/rt-thread/components/finsh/: shell.c msh_parse.c msh.c cmd.c msh_file.c
  group Kernel
    ../../../../os/rt-thread/src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../os/rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../os/rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../os/rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal.c stm32f1xx_hal_crc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cec.c stm32f1xx_hal_dma.c stm32f1xx_hal_usart.c stm32f1xx_hal_cortex.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
