# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: ..\..\..\..\os\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\os\rt-thread\libcpu\arm\cortex-m3;.;..\libraries\HAL_Drivers\CMSIS\Include;board;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\..\os\rt-thread\components\libc\compilers\common\include;..\libraries\HAL_Drivers\drivers;..\..\..\..\os\rt-thread\libcpu\arm\common;..\libraries\HAL_Drivers\drivers\config;board\ports;..\..\..\..\os\rt-thread\components\libc\posix\io\epoll;applications;..\libraries\HAL_Drivers;..\..\..\..\os\rt-thread\components\drivers\include;..\..\..\..\os\rt-thread\include;..\..\..\..\os\rt-thread\components\libc\posix\io\eventfd;..\..\..\..\os\rt-thread\components\libc\posix\io\poll;..\..\..\..\os\rt-thread\components\drivers\include;..\..\..\..\os\rt-thread\components\libc\compilers\common\extension;..\..\..\..\os\rt-thread\components\drivers\include;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\..\..\..\os\rt-thread\components\drivers\include;..\..\..\..\os\rt-thread\components\dfs\dfs_v1\include;..\..\..\..\os\rt-thread\components\libc\posix\ipc;..\..\..\..\os\rt-thread\components\finsh;board\CubeMX_Config\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../../os/rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../os/rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../os/rt-thread/components/drivers/core/: device.c
    ../../../../os/rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../os/rt-thread/components/drivers/pin/: pin.c
    ../../../../os/rt-thread/components/drivers/serial/: serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    board/ports/: user_key.c
  group Filesystem
    ../../../../os/rt-thread/components/dfs/dfs_v1/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
  group Finsh
    ../../../../os/rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../../os/rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../os/rt-thread/src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../os/rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../os/rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
